Commit message: Added rviz support

File: src/larry_description/urdf/robot.urdf (robot description, URDF)
Before this commit: robot my-robot, 1 links, 0 joints
Links:
- added link base_link
Joints:
- added joint base_joint: type fixed, parent base_link, child part_1, origin xyz=0 0 0 rpy=0 0 0
